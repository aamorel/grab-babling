Commit message: ugly parallelization with scoop

File: data/baxter_common/baxter_description/urdf/toms_baxter.urdf (robot description, URDF)
Before this commit: robot baxter, 57 links, 56 joints
Links:
- link base: mass None -> 1
